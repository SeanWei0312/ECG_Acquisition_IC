** sch_path: Design_Files/IC Design/Testbench/ANALOG_BLOCKS/FDOTA/CMFB/Close_Loop/CMFB_TB_CL_NOM.sch
**.subckt CMFB_TB_CL_NOM
CL CMFB_OUT AGND 10p m=1
IBIAS AGND B dc 40u
VAVDD AVDD 0 dc {AVDD_SET} ac 0
.save i(vavdd)
[expr {falsePERIOD}) ? "VREF CMFB_REF AGND dc {VCM_REF_DC} pwl(0 {VCM_LOW} {LOW_HOLD} {VCM_LOW} {LOW_RETURN}
+ {VCM_REF_DC} {HIGH_START} {VCM_REF_DC} {HIGH_RISE} {VCM_HIGH} {HIGH_HOLD} {VCM_HIGH} {HIGH_RETURN} {VCM_REF_DC}
+ {TRAN_STOP} {VCM_REF_DC}) ac 0
.save i(vref)
.save :(:)
.save "vrefcmfb_refagnd("vrefcmfb_refagnd)
.save dc(dc)
.save {vcm_ref_dc}({vcm_ref_dc})
.save pwl(0)
.save {vcm_low}({vcm_low})
.save {low_hold}({low_hold})
.save {vcm_low}({vcm_low})
.save {low_return}({low_return})
.save {vcm_ref_dc}({vcm_ref_dc})
.save {high_start}({high_start})
.save {vcm_ref_dc}({vcm_ref_dc})
.save {high_rise}({high_rise})
.save {vcm_high}({vcm_high})
.save {high_hold}({high_hold})
.save {vcm_high}({vcm_high})
.save {high_return}({high_return})
.save {vcm_ref_dc}({vcm_ref_dc})
.save {tran_stop}({tran_stop})
.save {vcm_ref_dc})({vcm_ref_dc})
.save ac(ac)
.save 0(0)
.save "}]("}])
VAVSS AGND 0 dc {AVSS_SET} ac 0
.save i(vavss)
VOUTBIAS VOUTBIAS AGND dc {VOUT_CM_BIAS} ac 0
VCMFBOUTBIAS CMFBBIAS AGND dc {CMFB_OUT_BIAS} ac 0
EPLANT VOUTCM VOUTBIAS CMFB_OUT CMFBBIAS {PLANT_GAIN}
xCMFB1 AVDD AGND VOUTCM CMFB_REF CMFB_OUT B CMFB
**** begin user architecture code

.include $::180MCU_MODELS/design.ngspice

.param sw_stat_global=0
.param sw_stat_mismatch=0

.lib $::180MCU_MODELS/sm141064.ngspice typical
.lib $::180MCU_MODELS/sm141064.ngspice res_typical
.lib $::180MCU_MODELS/sm141064.ngspice mimcap_typical
.lib $::180MCU_MODELS/sm141064.ngspice cap_mim
.lib $::180MCU_MODELS/sm141064.ngspice bjt_typical

.csparam PROC_ID=0



.control
destroy all
save all
set wr_vecnames
set wr_singlescale
option numdgt=15

shell mkdir -p
+ /foss/designs/ECG_Acquisition_IC/Measurement_Results/IC_Simulation/ANALOG_BLOCKS/FDOTA/CMFB/NOM.Result_txt

shell rm -f
+ /foss/designs/ECG_Acquisition_IC/Measurement_Results/IC_Simulation/ANALOG_BLOCKS/FDOTA/CMFB/NOM.Result_txt/NOM.cl_op.txt
shell rm -f
+ /foss/designs/ECG_Acquisition_IC/Measurement_Results/IC_Simulation/ANALOG_BLOCKS/FDOTA/CMFB/NOM.Result_txt/NOM.cl_dc.txt
shell rm -f
+ /foss/designs/ECG_Acquisition_IC/Measurement_Results/IC_Simulation/ANALOG_BLOCKS/FDOTA/CMFB/NOM.Result_txt/NOM.cl_tran.txt

let avdd_run = 3.3
let vcm_run  = avdd_run/2

alter @VAVDD[DC] = $&avdd_run
alter @VREF[DC]  = $&vcm_run

alter @VREF[ACMAG]  = 0
alter @VAVDD[ACMAG] = 0
alter @VAVSS[ACMAG] = 0

* Operating point
op

let op_vdd     = v(avdd)-v(agnd)
let op_ref     = v(cmfb_ref)-v(agnd)
let op_voutcm  = v(voutcm)-v(agnd)
let op_vcmfb   = v(cmfb_out)-v(agnd)
let op_error   = op_voutcm-op_ref

let op_ibias   = 40e-6
let op_idd     = -vavdd#branch
let op_power   = op_vdd*op_idd

wrdata
+ /foss/designs/ECG_Acquisition_IC/Measurement_Results/IC_Simulation/ANALOG_BLOCKS/FDOTA/CMFB/NOM.Result_txt/NOM.cl_op.txt op_vdd op_ref op_voutcm op_vcmfb op_error op_ibias op_idd op_power

* Closed-loop DC
dc VREF 0 3.3 0.01

let cl_ref     = v(cmfb_ref)-v(agnd)
let cl_voutcm  = v(voutcm)-v(agnd)
let cl_ideal   = cl_ref
let cl_vcmfb   = v(cmfb_out)-v(agnd)
let cl_error   = cl_voutcm-cl_ref

setscale cl_ref

wrdata
+ /foss/designs/ECG_Acquisition_IC/Measurement_Results/IC_Simulation/ANALOG_BLOCKS/FDOTA/CMFB/NOM.Result_txt/NOM.cl_dc.txt cl_voutcm cl_ideal cl_vcmfb cl_error

reset
save all

* Closed-loop transient
tran 1n 10u

let tr_ref     = v(cmfb_ref)-v(agnd)
let tr_voutcm  = v(voutcm)-v(agnd)
let tr_vcmfb   = v(cmfb_out)-v(agnd)
let tr_error   = tr_voutcm-tr_ref

setscale time

wrdata
+ /foss/designs/ECG_Acquisition_IC/Measurement_Results/IC_Simulation/ANALOG_BLOCKS/FDOTA/CMFB/NOM.Result_txt/NOM.cl_tran.txt tr_ref tr_voutcm tr_vcmfb tr_error

quit
.endc




.param AVDD_SET=3.3
.param AVSS_SET=0
.param TEMP_SET=27

.param VCM_REF_DC={AVDD_SET/2}
.param VOUT_CM_BIAS={AVDD_SET/2}
.param CMFB_OUT_BIAS=2.4832

.param PLANT_GAIN=500

.param VCM_LOW=1.55
.param VCM_HIGH=1.75

.param LOW_HOLD=1u
.param LOW_RETURN=1.01u

.param HIGH_START=4u
.param HIGH_RISE=4.01u
.param HIGH_HOLD=6u
.param HIGH_RETURN=6.01u

.param TRAN_STOP=10u

.temp {TEMP_SET}

.options gmin=1e-12 rshunt=1e12 method=gear
.nodeset v(B)=2.3 v(CMFB_OUT)={CMFB_OUT_BIAS} v(VOUTCM)={VCM_REF_DC}


**** end user architecture code
**.ends

* expanding   symbol:  ECG_Acquisition_IC/Design_Files/IC
*+ Design/Schematic/ANALOG_BLOCKS/FDOTA/CMFB/CMFB.sym # of pins=6
** sym_path: Design_Files/IC Design/Schematic/FD_OTA/CMFB/CMFB.sym
** sch_path: Design_Files/IC Design/Schematic/FD_OTA/CMFB/CMFB.sch
.subckt CMFB CMFB_DD CMFB_SS CMFB_IN CMFB_REF CMFB_OUT CMFB_B
*.iopin CMFB_DD
*.iopin CMFB_SS
*.ipin CMFB_IN
*.ipin CMFB_REF
*.opin CMFB_OUT
*.iopin CMFB_B
XM4 CMFB_OUT CMFB_OUT CMFB_DD CMFB_DD pfet_03v3 L=0.5u W=1u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=77
XM3 net2 net2 CMFB_DD CMFB_DD pfet_03v3 L=0.5u W=1u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=77
XM1 net2 CMFB_REF net1 CMFB_SS nfet_03v3 L=0.5u W=1u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=5
XM2 CMFB_OUT CMFB_IN net1 CMFB_SS nfet_03v3 L=0.5u W=1u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=5
XM5 net1 CMFB_B CMFB_SS CMFB_SS nfet_03v3 L=2u W=1u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=20
XM10 CMFB_B CMFB_B CMFB_SS CMFB_SS nfet_03v3 L=2u W=1u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=20
.ends

.GLOBAL AVDD
.end
