** sch_path: Design_Files/IC Design/Testbench/AFE_BLOCKS/PGA/PGA_TB_GL.sch
**.subckt PGA_TB_GL
CLP OUTP AGND {CL_SET} m=1
CLN OUTN AGND {CL_SET} m=1
xBIAS1 AVDD AGND BP BIAS
XMBFDC BFDC BP AVDD AVDD pfet_03v3 L=4u W=16u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XMBCMFB BCMFB BP AVDD AVDD pfet_03v3 L=4u W=16u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
VAVDD AVDD 0 dc {VDD_SET} ac 0
.save i(vavdd)
VAVSS AGND 0 dc 0 ac 0
VCM VCM AGND dc {VCM_SET} ac 0
[expr {falselse ? "VDIFF VDIFF AGND dc 0 ac 1 sin(0 {TRAN_AMP_SET} {TRAN_FREQ_SET})
.save i(vdiff)
.save :(:)
.save "vdiffvdiffagnd("vdiffvdiffagnd)
.save dc(dc)
.save 0(0)
.save ac(ac)
.save 1(1)
.save sin(0)
.save {tran_amp_set}({tran_amp_set})
.save {tran_freq_set})({tran_freq_set})
.save "}]("}])
VREF REF AGND dc {VREF_SET} ac 0
VSEL PGA_SEL AGND dc 0 ac 0 pulse(0 {SEL_TRAN_HIGH_SET} {SEL_SWITCH_TIME_SET} 1u 1u 400m 800m)
VEXTCM EXTVCM AGND dc {VCM_SET} ac 0
VEXTDIFF EXTVDIFF AGND dc 0 ac 0 sin(0 {EXT_TRAN_AMP_SET} {EXT_TRAN_FREQ_SET})
EINP INP VCM VDIFF AGND 0.5
EINN INN VCM VDIFF AGND -0.5
EEXTP PGA_EXTP EXTVCM EXTVDIFF AGND 0.5
EEXTN PGA_EXTN EXTVCM EXTVDIFF AGND -0.5
xPGA1 AVDD AGND INP INN PGA_OUTN BFDC PGA_OUTP BCMFB REF S1 S0 PGA
xMUXD3 AVDD AGND PGA_OUTP PGA_OUTN OUTN OUTP PGA_EXTP PGA_EXTN PGA_SEL MUXD
VS1 S1 AGND dc {S1_SET} ac 0
VS0 S0 AGND dc {S0_SET} ac 0
**** begin user architecture code

.include $::180MCU_MODELS/design.ngspice

.param sw_stat_global=1
.param sw_stat_mismatch=0

.param mc_skew=3
.param res_mc_skew=3
.param cap_mc_skew=3

.lib $::180MCU_MODELS/sm141064.ngspice statistical
.lib $::180MCU_MODELS/sm141064.ngspice res_statistical
.lib $::180MCU_MODELS/sm141064.ngspice mimcap_statistical
.lib $::180MCU_MODELS/sm141064.ngspice cap_mim
.lib $::180MCU_MODELS/sm141064.ngspice bjt_statistical

.csparam PROC_ID=6



.param VDD_SET=3.3
.param TEMP_SET=27

.param VCM_SET={VDD_SET/2}
.param VREF_SET={VDD_SET/2}

.param CL_SET=10p

.param S1_SET=0
.param S0_SET=0

.param PGA_G2_TARGET_SET=2
.param PGA_G4_TARGET_SET=4
.param PGA_G8_TARGET_SET=8
.param PGA_G16_TARGET_SET=16

.param TRAN_AMP_SET=50m
.param TRAN_FREQ_SET=10

.param EXT_TRAN_AMP_SET=0
.param EXT_TRAN_FREQ_SET=25

.param SEL_TRAN_HIGH_SET=0
.param SEL_SWITCH_TIME_SET=200m

.csparam MC_RUNS=200

.temp {TEMP_SET}

.options gmin=1e-12
.options rshunt=1e12
.options method=gear





.control

destroy all

set noaskquit
set wr_singlescale
unset wr_vecnames

option klu
option numdgt=15
option method=gear
option maxord=2
option plotwinsize=0


* Mode

if $&PROC_ID = 5
set mode=MM
set tag=mm
else
if $&PROC_ID = 6
set mode=GL
set tag=gl
else
set mode=FULL
set tag=full
end
end


* Condition

alterparam VDD_SET=3.3
alterparam TEMP_SET=27
alterparam SEL_TRAN_HIGH_SET=0
alterparam EXT_TRAN_AMP_SET=0

reset


* Output

shell mkdir -p /foss/designs/ECG_Acquisition_IC/Measurement_Results/IC_Simulation/AFE_BLOCKS/PGA/{$mode}.Result_txt

shell rm -f /foss/designs/ECG_Acquisition_IC/Measurement_Results/IC_Simulation/AFE_BLOCKS/PGA/{$mode}.Result_txt/{$tag}.op_mc_summary.txt
shell rm -f /foss/designs/ECG_Acquisition_IC/Measurement_Results/IC_Simulation/AFE_BLOCKS/PGA/{$mode}.Result_txt/{$tag}.g2_mc_summary.txt
shell rm -f /foss/designs/ECG_Acquisition_IC/Measurement_Results/IC_Simulation/AFE_BLOCKS/PGA/{$mode}.Result_txt/{$tag}.g4_mc_summary.txt
shell rm -f /foss/designs/ECG_Acquisition_IC/Measurement_Results/IC_Simulation/AFE_BLOCKS/PGA/{$mode}.Result_txt/{$tag}.g8_mc_summary.txt
shell rm -f /foss/designs/ECG_Acquisition_IC/Measurement_Results/IC_Simulation/AFE_BLOCKS/PGA/{$mode}.Result_txt/{$tag}.g16_mc_summary.txt


let run=1

dowhile run <= $&MC_RUNS

setseed $&run
mc_source


* Save after mc_source

save v(AVDD) v(AGND) v(REF)
save v(INP) v(INN)
save v(PGA_OUTP) v(PGA_OUTN)
save i(VAVDD)
save @m.xmbfdc.m0[id]
save @m.xmbcmfb.m0[id]


* Sources

alter @VAVDD[DC]=3.3
alter @VAVSS[DC]=0

alter @VCM[DC]=1.65
alter @VREF[DC]=1.65

alter @VSEL[DC]=0
alter @VDIFF[DC]=0

alter @VAVDD[ACMAG]=0
alter @VAVSS[ACMAG]=0
alter @VCM[ACMAG]=0
alter @VREF[ACMAG]=0
alter @VDIFF[ACMAG]=0
alter @VEXTDIFF[ACMAG]=0


* Four gains

foreach gcode 0 1 2 3

if $gcode = 0
set gtag=g2
set gain_target=2
set s1v=0
set s0v=0
else
if $gcode = 1
set gtag=g4
set gain_target=4
set s1v=0
set s0v=3.3
else
if $gcode = 2
set gtag=g8
set gain_target=8
set s1v=3.3
set s0v=0
else
set gtag=g16
set gain_target=16
set s1v=3.3
set s0v=3.3
end
end
end

alter @VS1[DC]=$s1v
alter @VS0[DC]=$s0v

alter @VDIFF[DC]=0

alter @VDIFF[ACMAG]=0
alter @VCM[ACMAG]=0
alter @VREF[ACMAG]=0
alter @VAVDD[ACMAG]=0
alter @VAVSS[ACMAG]=0
alter @VEXTDIFF[ACMAG]=0


* Offset

dc VDIFF -10m 10m 50u

let pga_diff=v(PGA_OUTP)-v(PGA_OUTN)

meas dc vos_meas when pga_diff=0 cross=1

set vos_val=$&vos_meas

destroy all


* Shared OP at G2

if $gcode = 0

alter @VDIFF[DC]=$vos_val

op

let pga_out_cm=0.5*(v(PGA_OUTP)+v(PGA_OUTN))-v(AGND)
let out_cm_error=pga_out_cm-v(REF)

let idd_total=abs(vavdd#branch)
let power_total=(v(AVDD)-v(AGND))*idd_total

let ibfdc=abs(@m.xmbfdc.m0[id])
let ibcmfb=abs(@m.xmbcmfb.m0[id])

set ibfdc_val=$&ibfdc
set ibcmfb_val=$&ibcmfb
set idd_val=$&idd_total
set power_val=$&power_total
set outcmerr_val=$&out_cm_error

echo $&run $ibfdc_val $ibcmfb_val $idd_val $power_val $outcmerr_val >> /foss/designs/ECG_Acquisition_IC/Measurement_Results/IC_Simulation/AFE_BLOCKS/PGA/{$mode}.Result_txt/{$tag}.op_mc_summary.txt

destroy all

end


* Differential AC

alter @VDIFF[DC]=$vos_val

alter @VDIFF[ACMAG]=1
alter @VCM[ACMAG]=0
alter @VREF[ACMAG]=0
alter @VAVDD[ACMAG]=0
alter @VAVSS[ACMAG]=0
alter @VEXTDIFF[ACMAG]=0

ac dec 50 10 20Meg

let vin_diff=v(INP)-v(INN)
let pga_diff=v(PGA_OUTP)-v(PGA_OUTN)

let pga_gain=mag(pga_diff/vin_diff)

meas ac gain10 find pga_gain at=10
meas ac gain60 find pga_gain at=60
meas ac gain150 find pga_gain at=150

let norm_db=20*log10(pga_gain/$&gain10)

meas ac bw3db when norm_db=-3 fall=1

set gain10_val=$&gain10
set gain60_val=$&gain60
set gain150_val=$&gain150
set bw3db_val=$&bw3db

if $gcode = 0
let gain_error_pct=100*($&gain10/2-1)
else
if $gcode = 1
let gain_error_pct=100*($&gain10/4-1)
else
if $gcode = 2
let gain_error_pct=100*($&gain10/8-1)
else
let gain_error_pct=100*($&gain10/16-1)
end
end
end

set gainerr_val=$&gain_error_pct

destroy all


* CMRR 60 Hz

alter @VDIFF[ACMAG]=0
alter @VCM[ACMAG]=1

ac lin 1 60 60

let vin_cm=v(INP)
let pga_diff=v(PGA_OUTP)-v(PGA_OUTN)

let acm60=mag(pga_diff/vin_cm)

set acm60_val=$&acm60

destroy all


* CMRR 150 Hz

ac lin 1 150 150

let vin_cm=v(INP)
let pga_diff=v(PGA_OUTP)-v(PGA_OUTN)

let acm150=mag(pga_diff/vin_cm)

set acm150_val=$&acm150

let cmrr60=20*log10($gain60_val/$acm60_val)
let cmrr150=20*log10($gain150_val/$acm150_val)

set cmrr60_val=$&cmrr60
set cmrr150_val=$&cmrr150

destroy all


* Gain output

echo $&run $vos_val $gain10_val $gainerr_val $gain150_val $bw3db_val $cmrr60_val $cmrr150_val >> /foss/designs/ECG_Acquisition_IC/Measurement_Results/IC_Simulation/AFE_BLOCKS/PGA/{$mode}.Result_txt/{$tag}.{$gtag}_mc_summary.txt

end


let run=run+1

end

quit

.endc



**** end user architecture code
**.ends
.end
