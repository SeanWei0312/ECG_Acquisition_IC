** sch_path: Design_Files/IC Design/Testbench/AFE_BLOCKS/PGA/PGA_TB_FF.sch
**.subckt PGA_TB_FF
CLP OUTP AGND {CL_SET} m=1
CLN OUTN AGND {CL_SET} m=1
xBIAS1 AVDD AGND BP BIAS
XMBFDC BFDC BP AVDD AVDD pfet_03v3 L=4u W=16u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
XMBCMFB BCMFB BP AVDD AVDD pfet_03v3 L=4u W=16u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf * 0.18u'
+ pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u / W'
+ sa=0 sb=0 sd=0 m=1
VAVDD AVDD 0 dc {VDD_SET} ac 0
.save i(vavdd)
VAVSS AGND 0 dc 0 ac 0
VCM VCM AGND dc {VCM_SET} ac 0
[expr {falselse ? "VDIFF VDIFF AGND dc 0 ac 1 sin(0 {TRAN_AMP_SET} {TRAN_FREQ_SET})
.save i(vdiff)
.save :(:)
.save "vdiffvdiffagnd("vdiffvdiffagnd)
.save dc(dc)
.save 0(0)
.save ac(ac)
.save 1(1)
.save sin(0)
.save {tran_amp_set}({tran_amp_set})
.save {tran_freq_set})({tran_freq_set})
.save "}]("}])
VREF REF AGND dc {VREF_SET} ac 0
VSEL PGA_SEL AGND dc 0 ac 0 pulse(0 {SEL_TRAN_HIGH_SET} {SEL_SWITCH_TIME_SET} 1u 1u 400m 800m)
VEXTCM EXTVCM AGND dc {VCM_SET} ac 0
VEXTDIFF EXTVDIFF AGND dc 0 ac 0 sin(0 {EXT_TRAN_AMP_SET} {EXT_TRAN_FREQ_SET})
EINP INP VCM VDIFF AGND 0.5
EINN INN VCM VDIFF AGND -0.5
EEXTP PGA_EXTP EXTVCM EXTVDIFF AGND 0.5
EEXTN PGA_EXTN EXTVCM EXTVDIFF AGND -0.5
xPGA1 AVDD AGND INP INN PGA_OUTN BFDC PGA_OUTP BCMFB REF S1 S0 PGA
xMUXD3 AVDD AGND PGA_OUTP PGA_OUTN OUTN OUTP PGA_EXTP PGA_EXTN PGA_SEL MUXD
VS1 S1 AGND dc {S1_SET} ac 0
VS0 S0 AGND dc {S0_SET} ac 0
**** begin user architecture code

.include $::180MCU_MODELS/design.ngspice

.param sw_stat_global=0
.param sw_stat_mismatch=0

.lib $::180MCU_MODELS/sm141064.ngspice ff
.lib $::180MCU_MODELS/sm141064.ngspice res_ff
.lib $::180MCU_MODELS/sm141064.ngspice mimcap_ff
.lib $::180MCU_MODELS/sm141064.ngspice cap_mim
.lib $::180MCU_MODELS/sm141064.ngspice bjt_ff

.csparam PROC_ID=1



.param VDD_SET=3.3
.param TEMP_SET=27

.param VCM_SET={VDD_SET/2}
.param VREF_SET={VDD_SET/2}

.param CL_SET=10p

.param S1_SET=0
.param S0_SET=0

.param PGA_G2_TARGET_SET=2
.param PGA_G4_TARGET_SET=4
.param PGA_G8_TARGET_SET=8
.param PGA_G16_TARGET_SET=16

.param TRAN_AMP_SET=50m
.param TRAN_FREQ_SET=10

.param EXT_TRAN_AMP_SET=0
.param EXT_TRAN_FREQ_SET=25

.param SEL_TRAN_HIGH_SET=0
.param SEL_SWITCH_TIME_SET=200m

.csparam MC_RUNS=200

.temp {TEMP_SET}

.options gmin=1e-12
.options rshunt=1e12
.options method=gear





.control

destroy all

set noaskquit
set wr_singlescale
unset wr_vecnames

option klu
option numdgt=15
option method=gear
option maxord=2
option plotwinsize=0

if $&PROC_ID = 0
set proc=NOM
else
if $&PROC_ID = 1
set proc=FF
else
if $&PROC_ID = 2
set proc=SS
else
if $&PROC_ID = 3
set proc=FS
else
set proc=SF
end
end
end
end

shell mkdir -p /foss/designs/ECG_Acquisition_IC/Measurement_Results/IC_Simulation/AFE_BLOCKS/PGA/{$proc}.Result_txt
shell rm -f /foss/designs/ECG_Acquisition_IC/Measurement_Results/IC_Simulation/AFE_BLOCKS/PGA/{$proc}.Result_txt/{$proc}.*.txt

foreach vddval 3.3 3.0 3.6
foreach tval 27 -40 125

if $vddval = 3.3
if $tval = 27
set env=nom
else
if $tval = -40
set env=tl
else
set env=th
end
end
else
if $vddval = 3.0
if $tval = 27
set env=vl
else
if $tval = -40
set env=vltl
else
set env=vlth
end
end
else
if $tval = 27
set env=vh
else
if $tval = -40
set env=vhtl
else
set env=vhth
end
end
end
end

alterparam VDD_SET=$vddval
alterparam TEMP_SET=$tval
alterparam SEL_TRAN_HIGH_SET=0
alterparam EXT_TRAN_AMP_SET=0

foreach gcode 0 1 2 3

if $gcode = 0
set gtag=g2
set gain_target=2
set s1v=0
set s0v=0
else
if $gcode = 1
set gtag=g4
set gain_target=4
set s1v=0
set s0v=$vddval
else
if $gcode = 2
set gtag=g8
set gain_target=8
set s1v=$vddval
set s0v=0
else
set gtag=g16
set gain_target=16
set s1v=$vddval
set s0v=$vddval
end
end
end

reset

alter @VS1[DC]=$s1v
alter @VS0[DC]=$s0v
alter @VSEL[DC]=0

alter @VDIFF[DC]=0

alter @VDIFF[ACMAG]=0
alter @VCM[ACMAG]=0
alter @VREF[ACMAG]=0
alter @VEXTDIFF[ACMAG]=0
alter @VAVDD[ACMAG]=0
alter @VAVSS[ACMAG]=0

save all
save @m.xmbfdc.m0[id]
save @m.xmbcmfb.m0[id]


* OFFSET

dc VDIFF -20m 20m 10u

let pga_diff=v(PGA_OUTP)-v(PGA_OUTN)

meas dc vos_meas when pga_diff=0 cross=1

set vos_val=$&vos_meas

echo $vos_val > /foss/designs/ECG_Acquisition_IC/Measurement_Results/IC_Simulation/AFE_BLOCKS/PGA/{$proc}.Result_txt/{$proc}.vos_{$gtag}_{$env}.txt

destroy all

alter @VDIFF[DC]=$vos_val


* OP

op

let op_index=0

let vdd=v(AVDD)-v(AGND)
let vref=v(REF)-v(AGND)

let vin_cm=0.5*(v(INP)+v(INN))-v(AGND)
let vin_diff=v(INP)-v(INN)

let pga_out_cm=0.5*(v(PGA_OUTP)+v(PGA_OUTN))-v(AGND)
let pga_out_diff=v(PGA_OUTP)-v(PGA_OUTN)
let pga_cm_error=pga_out_cm-vref

let out_cm=0.5*(v(OUTP)+v(OUTN))-v(AGND)
let out_diff=v(OUTP)-v(OUTN)

let idd_total=abs(vavdd#branch)
let power_total=vdd*idd_total

let ibfdc=abs(@m.xmbfdc.m0[id])
let ibcmfb=abs(@m.xmbcmfb.m0[id])

setscale op_index

wrdata /foss/designs/ECG_Acquisition_IC/Measurement_Results/IC_Simulation/AFE_BLOCKS/PGA/{$proc}.Result_txt/{$proc}.op_{$gtag}_{$env}.txt vdd vref v(S1) v(S0) vin_cm vin_diff pga_out_cm pga_out_diff pga_cm_error out_cm out_diff idd_total power_total ibfdc ibcmfb

destroy all


* DIFF AC

alter @VDIFF[ACMAG]=1
alter @VCM[ACMAG]=0
alter @VREF[ACMAG]=0
alter @VEXTDIFF[ACMAG]=0
alter @VAVDD[ACMAG]=0
alter @VAVSS[ACMAG]=0

ac dec 150 0.01 100Meg

let vin_diff=v(INP)-v(INN)
let pga_diff=v(PGA_OUTP)-v(PGA_OUTN)
let out_diff=v(OUTP)-v(OUTN)

let vin_r=real(vin_diff)
let vin_i=imag(vin_diff)

let pga_r=real(pga_diff)
let pga_i=imag(pga_diff)

let out_r=real(out_diff)
let out_i=imag(out_diff)

setscale frequency

wrdata /foss/designs/ECG_Acquisition_IC/Measurement_Results/IC_Simulation/AFE_BLOCKS/PGA/{$proc}.Result_txt/{$proc}.diff_ac_{$gtag}_{$env}.txt vin_r vin_i pga_r pga_i out_r out_i

destroy all


* CMRR

alter @VDIFF[ACMAG]=0
alter @VCM[ACMAG]=1
alter @VREF[ACMAG]=0
alter @VEXTDIFF[ACMAG]=0
alter @VAVDD[ACMAG]=0
alter @VAVSS[ACMAG]=0

ac dec 100 0.01 1Meg

let vin_cm=0.5*(v(INP)+v(INN))-v(AGND)
let pga_diff=v(PGA_OUTP)-v(PGA_OUTN)

let vin_r=real(vin_cm)
let vin_i=imag(vin_cm)

let out_r=real(pga_diff)
let out_i=imag(pga_diff)

setscale frequency

wrdata /foss/designs/ECG_Acquisition_IC/Measurement_Results/IC_Simulation/AFE_BLOCKS/PGA/{$proc}.Result_txt/{$proc}.cmrr_ac_{$gtag}_{$env}.txt vin_r vin_i out_r out_i

destroy all


* PSRR+

alter @VDIFF[ACMAG]=0
alter @VCM[ACMAG]=0
alter @VREF[ACMAG]=0
alter @VEXTDIFF[ACMAG]=0
alter @VAVDD[ACMAG]=1
alter @VAVDD[ACPHASE]=0
alter @VAVSS[ACMAG]=0

ac dec 100 0.01 1Meg

let vsup=v(AVDD)-v(AGND)
let pga_diff=v(PGA_OUTP)-v(PGA_OUTN)

let vsup_r=real(vsup)
let vsup_i=imag(vsup)

let out_r=real(pga_diff)
let out_i=imag(pga_diff)

setscale frequency

wrdata /foss/designs/ECG_Acquisition_IC/Measurement_Results/IC_Simulation/AFE_BLOCKS/PGA/{$proc}.Result_txt/{$proc}.psrrp_ac_{$gtag}_{$env}.txt vsup_r vsup_i out_r out_i

destroy all


* PSRR-

alter @VDIFF[ACMAG]=0
alter @VCM[ACMAG]=0
alter @VREF[ACMAG]=0
alter @VEXTDIFF[ACMAG]=0
alter @VAVDD[ACMAG]=0
alter @VAVSS[ACMAG]=1
alter @VAVSS[ACPHASE]=0

ac dec 100 0.01 1Meg

let vsup=v(AVDD)-v(AGND)
let pga_diff=v(PGA_OUTP)-v(PGA_OUTN)

let vsup_r=real(vsup)
let vsup_i=imag(vsup)

let out_r=real(pga_diff)
let out_i=imag(pga_diff)

setscale frequency

wrdata /foss/designs/ECG_Acquisition_IC/Measurement_Results/IC_Simulation/AFE_BLOCKS/PGA/{$proc}.Result_txt/{$proc}.psrrn_ac_{$gtag}_{$env}.txt vsup_r vsup_i out_r out_i

destroy all


* NOISE

alter @VDIFF[ACMAG]=1
alter @VCM[ACMAG]=0
alter @VREF[ACMAG]=0
alter @VEXTDIFF[ACMAG]=0
alter @VAVDD[ACMAG]=0
alter @VAVSS[ACMAG]=0

noise v(PGA_OUTP,PGA_OUTN) VDIFF dec 100 0.01 10k

setplot previous
setscale frequency

wrdata /foss/designs/ECG_Acquisition_IC/Measurement_Results/IC_Simulation/AFE_BLOCKS/PGA/{$proc}.Result_txt/{$proc}.noise_{$gtag}_{$env}.txt onoise_spectrum inoise_spectrum

destroy all

end

end
end


* SEL FUNCTIONAL

if $&PROC_ID = 0

alterparam VDD_SET=3.3
alterparam TEMP_SET=27

alterparam TRAN_AMP_SET=50m
alterparam TRAN_FREQ_SET=10

alterparam EXT_TRAN_AMP_SET=50m
alterparam EXT_TRAN_FREQ_SET=25

alterparam SEL_TRAN_HIGH_SET=3.3
alterparam SEL_SWITCH_TIME_SET=200m

reset

alter @VS1[DC]=0
alter @VS0[DC]=0

save all

tran 20u 400m

let int_diff=v(PGA_OUTP)-v(PGA_OUTN)
let ext_diff=v(PGA_EXTP)-v(PGA_EXTN)
let out_diff=v(OUTP)-v(OUTN)

wrdata /foss/designs/ECG_Acquisition_IC/Measurement_Results/IC_Simulation/AFE_BLOCKS/PGA/{$proc}.Result_txt/{$proc}.sel_tran_nom.txt v(PGA_SEL) int_diff ext_diff out_diff

destroy all

end


* GAIN SWITCH FUNCTIONAL

if $&PROC_ID = 0

alterparam VDD_SET=3.3
alterparam TEMP_SET=27

alterparam TRAN_AMP_SET=50m
alterparam TRAN_FREQ_SET=10

alterparam EXT_TRAN_AMP_SET=0
alterparam SEL_TRAN_HIGH_SET=0

reset

alter @VS1[DC]=0
alter @VS0[DC]=0
alter @VSEL[DC]=0

compose S1PWL values 0 0 199.98m 0 200m 3.3 400m 3.3

compose S0PWL values 0 0 99.98m 0 100m 3.3 199.98m 3.3 200m 0 299.98m 0 300m 3.3 400m 3.3

alter @VS1[pwl]=S1PWL
alter @VS0[pwl]=S0PWL

save all

tran 20u 400m

let vin_diff=v(INP)-v(INN)
let pga_diff=v(PGA_OUTP)-v(PGA_OUTN)

setscale time

wrdata /foss/designs/ECG_Acquisition_IC/Measurement_Results/IC_Simulation/AFE_BLOCKS/PGA/{$proc}.Result_txt/{$proc}.gain_switch_tran_nom.txt v(S1) v(S0) vin_diff pga_diff

destroy all

end

quit

.endc



**** end user architecture code
**.ends
.end
