v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 140 -520 160 -520 {lab=BUFFER_DD}
N 140 -480 160 -480 {lab=BUFFER_SS}
N 140 -440 160 -440 {lab=BUFFER_INP}
N 140 -400 160 -400 {lab=BUFFER_INN}
N 140 -360 160 -360 {lab=BUFFER_OUTP}
N 140 -280 160 -280 {lab=BUFFER_BFDC}
N 140 -320 160 -320 {lab=BUFFER_OUTN}
N 140 -240 160 -240 {lab=BUFFER_BCMFB}
N 140 -200 160 -200 {lab=BUFFER_REF}
C {title.sym} 160 -40 0 0 {name=l1 author="Yi-Hsiang Wei"}
C {iopin.sym} 140 -520 0 1 {name=p8 lab=BUFFER_DD}
C {iopin.sym} 140 -480 0 1 {name=p9 lab=BUFFER_SS}
C {lab_wire.sym} 160 -520 0 1 {name=p11 sig_type=std_logic lab=BUFFER_DD}
C {lab_wire.sym} 160 -480 0 1 {name=p12 sig_type=std_logic lab=BUFFER_SS}
C {ipin.sym} 140 -440 0 0 {name=p13 lab=BUFFER_INP}
C {ipin.sym} 140 -400 0 0 {name=p14 lab=BUFFER_INN}
C {lab_wire.sym} 160 -440 0 1 {name=p15 sig_type=std_logic lab=BUFFER_INP}
C {lab_wire.sym} 160 -400 0 1 {name=p16 sig_type=std_logic lab=BUFFER_INN}
C {opin.sym} 140 -360 0 1 {name=p17 lab=BUFFER_OUTP}
C {lab_wire.sym} 160 -360 0 1 {name=p18 sig_type=std_logic lab=BUFFER_OUTP}
C {iopin.sym} 140 -280 0 1 {name=p1 lab=BUFFER_BFDC}
C {lab_wire.sym} 160 -280 0 1 {name=p19 sig_type=std_logic lab=BUFFER_BFDC}
C {opin.sym} 140 -320 0 1 {name=p23 lab=BUFFER_OUTN}
C {lab_wire.sym} 160 -320 0 1 {name=p24 sig_type=std_logic lab=BUFFER_OUTN}
C {iopin.sym} 140 -240 0 1 {name=p25 lab=BUFFER_BCMFB}
C {lab_wire.sym} 160 -240 0 1 {name=p26 sig_type=std_logic lab=BUFFER_BCMFB}
C {iopin.sym} 140 -200 0 1 {name=p29 lab=BUFFER_REF}
C {lab_wire.sym} 160 -200 0 1 {name=p30 sig_type=std_logic lab=BUFFER_REF}
